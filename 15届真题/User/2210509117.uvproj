# Keil uVision project 2210509117.uvproj, settings and files
target 2210509117 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 2210509117 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver;..\..\15届真题
  group User
    ./: STARTUP.A51 main.c
  group Driver
    ../Driver/: ds1302.c iic.c key.c led.c seg.c key.h led.h seg.h init.c
